# Keil uVision project COD_H7_Template.uvprojx, settings and files
target COD_H7_Template (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: COD_H7_Template +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U,ARM_MATH_CHECK
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../Task/Inc;../Device/Inc;../Algorithm/Inc;../Middlewares/ST/ARM/DSP/Inc;../API/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../SystemView/SEGGER;../SystemView/Sample/FreeRTOSV10;../SystemView/Config;../SystemView/SEGGER/Syscalls;../SystemView/Sample/FreeRTOSV10/Patch;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: COD_H7_Template\COD_H7_Template.sct
  group API
    ../API/Src/: Quaternion.c
  group Task
    ../Task/Src/: INS_Task.c Control_Task.c MPC_Task.c CAN_Task.c Power_Ctrl.c
    ../Task/Inc/: Config.h
  group Device
    ../Device/Src/: Motor.c remote_control.c Referee_System.c Bmi088.c HIPNUC.c
    ../Device/Inc/: Bmi088_Reg.h
  group Bsp
    ../BSP/Src/: bsp_can.c bsp_uart.c bsp_gpio.c bsp_tick.c bsp_rs485.c bsp_spi.c
  group Algorithm
    ../Algorithm/Src/: Kalman_Filter.c lpf.c pid.c ramp.c CRC.c RLS.c ADRC.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfdp_math.lib
  group SystemView
    ../SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../SystemView/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../SystemView/Sample/FreeRTOSV10/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
software components: CMSIS:CORE 5.5.0
